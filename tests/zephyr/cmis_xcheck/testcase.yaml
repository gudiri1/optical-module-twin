## tests/zephyr/cmis_xcheck/testcase.yaml
```yaml
# SPDX-License-Identifier: Apache-2.0
tests:
  omt.cmis_xcheck:
    platform_allow: native_sim/native/64
    tags: cmis
    harness: ztest
```
